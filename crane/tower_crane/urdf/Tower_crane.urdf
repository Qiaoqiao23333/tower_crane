Commit message: fix: map pdo succeful !

File: crane/tower_crane/urdf/Tower_crane.urdf (robot description, URDF)
Before this commit: robot tower_crane, 6 links, 5 joints
Joints:
- joint trolley_joint: limit lower=-2 upper=0.5 effort=20 velocity=0.5 -> lower=-1.0 upper=0.5 effort=20 velocity=0.5
